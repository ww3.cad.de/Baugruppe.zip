# Autodesk Inventor assembly: Stihl_1
## iProperties
Created: 2007-01
Part Number: Stihl_1
Document SubType Name: Assembly
Designer: Jürgen
Author: Jürgen
